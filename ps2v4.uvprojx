# Keil uVision project ps2v4.uvprojx, settings and files
target SP2-V4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ps2v4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10x_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\HARDWARE\LED;..\HARDWARE\move;..\HARDWARE\PS2;..\HARDWARE\time;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\BLUEBOOTH;..\HARDWARE\MOTOR;..\HARDWARE\DMA;..\STM32F10x_FWLib\src;..\HARDWARE;..\HARDWARE;..\HARDWARE\Optical;..\HARDWARE\OLED-SPI;..\HARDWARE\MOTOR
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../HARDWARE/MOTOR/: User_parameter.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PS2/: pstwo.c
    ../HARDWARE/time/: time.c
    ../HARDWARE/BLUEBOOTH/: bluebooth.c
    ../HARDWARE/MOTOR/: motor.c method_control.c PID_SZJ.c list.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/: control.c
    ../HARDWARE/OLED-SPI/: oled.c
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_adc.c
    ../STM32F10x_FWLib/inc/: stm32f10x_adc.h
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
